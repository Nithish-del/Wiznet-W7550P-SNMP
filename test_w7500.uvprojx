# Keil uVision project test_w7500.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: test_w7500 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\Libraries\W7500x_stdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;..\test_w7500;..\ioLibrary;..\ioLibrary\Ethernet;..\ioLibrary\MDIO;..\ioLibrary\Internet;..\ioLibrary\Application;..\ioLibrary\Internet\DNS;..\ioLibrary\Internet\DHCP;..\ioLibrary\Internet\httpServer;..\ioLibrary\Internet\SNMP;..\ioLibrary\Application\loopback;..\src;..\src\Configuration;..\src\Callback;..\src\PlatformHandler;..\src\Serial_to_Ethernet;..\Projects\Peripheral_Examples\WZTOE\httpServer
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MDK_ARM
    ../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_adc.c W7500x_crg.c W7500x_dma.c W7500x_dualtimer.c W7500x_exti.c W7500x_pwm.c W7500x_rng.c W7500x_ssp.c W7500x_uart.c W7500x_wdt.c W7500x_wztoe.c
  group User
    ./: main.c W7500x_it.c
    ../src/: W7500x_board.c retarget.c
  group ioLibrary
    ../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../ioLibrary/Internet/DNS/: dns.c
    ../ioLibrary/Internet/DHCP/: dhcp.c
    ../ioLibrary/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
    ../ioLibrary/Application/loopback/: loopback.c
    ../ioLibrary/MDIO/: W7500x_miim.c
    ../ioLibrary/Internet/SNMP/: snmp.c snmp_custom.c
  group callBack
    ../src/Configuration/: ConfigData.c segcp.c util.c
    ../src/Callback/: dhcp_cb.c
    ../src/Serial_to_Ethernet/: seg.c
    ../ioLibrary/Application/loopback/: loopback.c
  group plattformHandler
    ../src/PlatformHandler/: deviceHandler.c eepromHandler.c flashHandler.c gpioHandler.c i2cHandler.c isr_vector.c storageHandler.c timerHandler.c uartHandler.c
    ../ioLibrary/Internet/SNMP/: spi_handler.c
